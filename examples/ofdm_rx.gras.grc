<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_rx_gras</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>value</key><value>2412000000.0</value></param>
<param><key>choices</key><value>[2412000000.0, 2417000000.0, 2422000000.0, 2427000000.0, 2432000000.0, 2437000000.0, 2442000000.0, 2447000000.0, 2452000000.0, 2457000000.0, 2462000000.0, 2467000000.0, 2472000000.0, 2484000000.0, 5170000000.0, 5180000000.0, 5190000000.0, 5200000000.0, 5210000000.0, 5220000000.0, 5230000000.0, 5240000000.0, 5260000000.0, 5280000000.0, 5300000000.0, 5320000000.0, 5500000000.0, 5520000000.0, 5540000000.0, 5560000000.0, 5580000000.0, 5600000000.0, 5620000000.0, 5640000000.0, 5660000000.0, 5680000000.0, 5700000000.0, 5745000000.0, 5765000000.0, 5785000000.0, 5805000000.0, 5825000000.0, 5860000000.0, 5870000000.0, 5880000000.0, 5890000000.0, 5900000000.0, 5910000000.0, 5920000000.0]</value></param>
<param><key>labels</key><value>['  1 | 2412.0 | 11g', '  2 | 2417.0 | 11g', '  3 | 2422.0 | 11g', '  4 | 2427.0 | 11g', '  5 | 2432.0 | 11g', '  6 | 2437.0 | 11g', '  7 | 2442.0 | 11g', '  8 | 2447.0 | 11g', '  9 | 2452.0 | 11g', ' 10 | 2457.0 | 11g', ' 11 | 2462.0 | 11g', ' 12 | 2467.0 | 11g', ' 13 | 2472.0 | 11g', ' 14 | 2484.0 | 11g', ' 34 | 5170.0 | 11a', ' 36 | 5180.0 | 11a', ' 38 | 5190.0 | 11a', ' 40 | 5200.0 | 11a', ' 42 | 5210.0 | 11a', ' 44 | 5220.0 | 11a', ' 46 | 5230.0 | 11a', ' 48 | 5240.0 | 11a', ' 52 | 5260.0 | 11a', ' 56 | 5280.0 | 11a', ' 58 | 5300.0 | 11a', ' 60 | 5320.0 | 11a', '100 | 5500.0 | 11a', '104 | 5520.0 | 11a', '108 | 5540.0 | 11a', '112 | 5560.0 | 11a', '116 | 5580.0 | 11a', '120 | 5600.0 | 11a', '124 | 5620.0 | 11a', '128 | 5640.0 | 11a', '132 | 5660.0 | 11a', '136 | 5680.0 | 11a', '140 | 5700.0 | 11a', '149 | 5745.0 | 11a', '153 | 5765.0 | 11a', '157 | 5785.0 | 11a', '161 | 5805.0 | 11a', '165 | 5825.0 | 11a', '172 | 5860.0 | 11p', '174 | 5870.0 | 11p', '176 | 5880.0 | 11p', '178 | 5890.0 | 11p', '180 | 5900.0 | 11p', '182 | 5910.0 | 11p', '184 | 5920.0 | 11p']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_size</value></param>
<param><key>value</key><value>48</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync_length</value></param>
<param><key>value</key><value>320 - 64</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value></value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/ofdm_sym.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/ofdm_fft.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>64</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value></value></param>
<param><key>shift</key><value>True</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/ofdm_long.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>ieee802_1_ofdm_equalize_symbols</key>
<param><key>id</key><value>ieee802_1_ofdm_equalize_symbols_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>64</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>48</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_sink</key>
<param><key>id</key><value>gr_file_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/tmp/ofdm_short_in.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>unbuffered</key><value>False</value></param>
</block>
<block>
<key>gr_tuntap_pdu</key>
<param><key>id</key><value>gr_tuntap_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>ifn</key><value>tun0</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb, 4</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>trig_mode</key><value>gr.gr_TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['FFT', 'Scope', 'Cor', 'Sync Short', 'Sync Long']</value></param>
</block>
<block>
<key>gr_socket_pdu</key>
<param><key>id</key><value>gr_socket_pdu_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>mtu</key><value>10000</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>extras_query_server</key>
<param><key>id</key><value>extras_query_server_0</value></param>
<param><key>name</key><value>top_block</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<block>
<key>ieee802_1_ofdm_decode_signal</key>
<param><key>id</key><value>ieee802_1_ofdm_decode_signal_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>48</value></param>
</block>
<block>
<key>ieee802_1_ofdm_decode_mac</key>
<param><key>id</key><value>ieee802_1_ofdm_decode_mac_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>extras_tuntap</key>
<param><key>id</key><value>extras_tuntap_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>dev</key><value></value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>20e6</value></param>
<param><key>choices</key><value>[10e6, 20e6]</value></param>
<param><key>labels</key><value>["10 Mhz", "20 Mhz"]</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>16</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>extras_delay</key>
<param><key>id</key><value>extras_delay_0</value></param>
<param><key>item_size</key><value>8</value></param>
<param><key>delay</key><value>16</value></param>
</block>
<block>
<key>gr_delay</key>
<param><key>id</key><value>gr_delay_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>sync_length</value></param>
<param><key>num_ports</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>ieee802_1_ofdm_sync_long</key>
<param><key>id</key><value>ieee802_1_ofdm_sync_long_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>sync_length</key><value>sync_length</value></param>
<param><key>freq_est</key><value>100</value></param>
</block>
<block>
<key>extras_delay</key>
<param><key>id</key><value>extras_delay_0_0</value></param>
<param><key>item_size</key><value>8</value></param>
<param><key>delay</key><value>256</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1]*window_size</value></param>
</block>
<block>
<key>gr_skiphead</key>
<param><key>id</key><value>gr_skiphead_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>20000000</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>extras_multiply</key>
<param><key>id</key><value>extras_multiply_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_conjugate_cc</key>
<param><key>id</key><value>gr_conjugate_cc_0</value></param>
</block>
<block>
<key>gr_complex_to_mag_squared</key>
<param><key>id</key><value>gr_complex_to_mag_squared_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_divide_xx</key>
<param><key>id</key><value>gr_divide_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>ieee802_1_ofdm_sync_short</key>
<param><key>id</key><value>ieee802_1_ofdm_sync_short_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>threshold</key><value>0.8</value></param>
<param><key>max_samples</key><value>80 * 80</value></param>
<param><key>min_plateau</key><value>2</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[1]*window_size</value></param>
</block>
<block>
<key>extras_divide</key>
<param><key>id</key><value>extras_divide_0</value></param>
<param><key>type</key><value>f32_f32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gr_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>gr_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>gr_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_squared_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>gr_divide_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>gr_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>gr_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_long_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_short_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_divide_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_long_0</source_block_id><sink_block_id>gr_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_long_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_long_0</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_short_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_delay_0_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_divide_xx_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_delay_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_short_0</source_block_id><sink_block_id>gr_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_decode_signal_0</source_block_id><sink_block_id>ieee802_1_ofdm_decode_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_equalize_symbols_0</source_block_id><sink_block_id>ieee802_1_ofdm_decode_signal_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0</source_block_id><sink_block_id>gr_file_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>gr_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>ieee802_1_ofdm_equalize_symbols_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_divide_xx_0</source_block_id><sink_block_id>gr_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_0</source_block_id><sink_block_id>gr_file_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_equalize_symbols_0</source_block_id><sink_block_id>gr_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>gr_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>extras_tuntap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_decode_mac_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_decode_mac_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_decode_signal_0</source_block_id><sink_block_id>gr_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>extras_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_delay_0</source_block_id><sink_block_id>gr_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_delay_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_delay_0_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_long_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>ieee802_1_ofdm_sync_short_0</source_block_id><sink_block_id>extras_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_multiply_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_skiphead_0</source_block_id><sink_block_id>extras_multiply_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_conjugate_cc_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_conjugate_cc_0</source_block_id><sink_block_id>extras_multiply_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>extras_divide_0</source_block_id><sink_block_id>ieee802_1_ofdm_sync_short_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>extras_divide_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>extras_divide_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
